# Keil uVision project HW477Test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.6.1
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: HW477Test
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L476RGTx/STCubeGenerated/Inc/: stm32l4xx_it.h i2c-lcd.h main.h stm32l4xx_hal_conf.h
    C:/Users/harry/Documents/Analog_TemperatureSensor_Test/RTE/Device/STM32L476RGTx/: FrameworkCubeMX.gpdsc
    ./RTE/Device/STM32L476RGTx/: MX_Device.h startup_stm32l476xx.s system_stm32l4xx.c
software components: CMSIS:CORE 5.5.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:ADC 1.13.0, Device:STM32Cube HAL:CAN 1.13.0, Device:STM32Cube HAL:COMP 1.13.0, Device:STM32Cube HAL:CRC 1.13.0, Device:STM32Cube HAL:Common 1.13.0, Device:STM32Cube HAL:Cortex 1.13.0, Device:STM32Cube HAL:DAC 1.13.0, Device:STM32Cube HAL:DFSDM 1.13.0, Device:STM32Cube HAL:DMA 1.13.0, Device:STM32Cube HAL:EXTI 1.13.0, Device:STM32Cube HAL:FIREWALL 1.13.0, Device:STM32Cube HAL:GPIO 1.13.0, Device:STM32Cube HAL:HCD 1.13.0, Device:STM32Cube HAL:I2C 1.13.0, Device:STM32Cube HAL:IRDA 1.13.0, Device:STM32Cube HAL:IWDG 1.13.0, Device:STM32Cube HAL:LCD 1.13.0, Device:STM32Cube HAL:LPTIM 1.13.0, Device:STM32Cube HAL:MMC 1.13.0, Device:STM32Cube HAL:NAND 1.13.0, Device:STM32Cube HAL:NOR 1.13.0, Device:STM32Cube HAL:OPAMP 1.13.0, Device:STM32Cube HAL:PCD 1.13.0, Device:STM32Cube HAL:PWR 1.13.0, Device:STM32Cube HAL:QSPI 1.13.0, Device:STM32Cube HAL:RCC 1.13.0, Device:STM32Cube HAL:RNG 1.13.0, Device:STM32Cube HAL:RTC 1.13.0, Device:STM32Cube HAL:SAI 1.13.0, Device:STM32Cube HAL:SD 1.13.0, Device:STM32Cube HAL:SMBUS 1.13.0, Device:STM32Cube HAL:SPI 1.13.0, Device:STM32Cube HAL:SRAM 1.13.0, Device:STM32Cube HAL:SWPMI 1.13.0, Device:STM32Cube HAL:Smartcard 1.13.0, Device:STM32Cube HAL:TIM 1.13.0, Device:STM32Cube HAL:TSC 1.13.0, Device:STM32Cube HAL:UART 1.13.0, Device:STM32Cube HAL:USART 1.13.0, Device:STM32Cube HAL:WWDG 1.13.0, Device:Startup 1.3.1
